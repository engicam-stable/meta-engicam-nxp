FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_imx8mp-icore-2e-mac += "file://0001-mx8mp-icore-2e-net-mac-devicetree-added.patch"
