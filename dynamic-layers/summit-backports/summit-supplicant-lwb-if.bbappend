SUMMIT_URI_BASE:mx95-icore = "https://github.com/Ezurio/SonaNX-Release-Packages/releases/download/LRD-REL-${PV}"
RADIO_VERSION:mx95-icore := "12.103.8.3"

SRC_URI[summit-supplicant-src.md5sum] = "45d57fee6bb291078b6e233d87eebf65"
SRC_URI[summit-supplicant-src.sha256sum] = "f457e2d77361c7925c26b48dce6fb118982e2861cab0e70cb458538b31278220"
