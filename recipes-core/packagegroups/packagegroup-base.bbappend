# Comment this if do NOT you want to use iwd to bypass
# brcmfmac/wpa_supplicant-2.11 issue
WIRELESS_DAEMON = "iwd"