PACKAGECONFIG_remove_pn-systemd = " networkd "
