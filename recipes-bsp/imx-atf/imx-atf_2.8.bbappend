FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-iMX8M-Mini-removed-UART4-from-M4.patch"

