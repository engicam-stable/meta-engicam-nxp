FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-imx95-Assign-GPIO1-pins-to-non-secure-world-in-BL31-.patch"

SRCREV = "1b27ee3edbb40ef9432c69ccaa744d1ac5d54c5d"
