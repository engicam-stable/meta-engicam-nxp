SUMMIT_URI_BASE:mx95-icore = "https://github.com/Ezurio/SonaNX-Release-Packages/releases/download/LRD-REL-${PV}"
RADIO_VERSION:mx95-icore := "12.103.8.3"

SRC_URI[summit-backports.md5sum] = "97f1cf9f5ed91d24b7673938d239aaba"
SRC_URI[summit-backports.sha256sum] = "52e2686473f1bbae7b6a115787e7d2c25c50daec901af130ac8c2cc0e96b361c"