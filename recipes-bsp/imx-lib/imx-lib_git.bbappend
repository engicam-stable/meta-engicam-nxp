PLATFORM_mx6ull = "IMX6UL"
