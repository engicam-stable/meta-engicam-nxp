FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-m33-debug-port-works.patch \
file://0002-system-boots.patch \
file://0003-added-Smarcore-MX95.patch \
"

