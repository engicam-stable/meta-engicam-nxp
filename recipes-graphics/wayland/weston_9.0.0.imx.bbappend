FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

FILES_${PN} += "${bindir}/weston-touch-calibrator"


