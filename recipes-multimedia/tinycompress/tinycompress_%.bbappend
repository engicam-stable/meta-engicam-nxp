SRC_URI = "git://github.com/alsa-project/tinycompress;protocol=https;branch=master \
"
